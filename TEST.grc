options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: am_co_freq
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: audio_value
  id: variable
  parameters:
    value: '0.4'
  states: {}
- name: demod_mode
  id: variable
  parameters:
    value: '2'
  states: {}
- name: dev_args
  id: variable
  parameters:
    value: '''rtl=0,direct_samp=0'''
  states: {}
- name: gain_bb
  id: variable
  parameters:
    value: '20'
  states: {}
- name: gain_if
  id: variable
  parameters:
    value: '20'
  states: {}
- name: gain_rf
  id: variable
  parameters:
    value: '20'
  states: {}
- name: lsb_co_freq_high
  id: variable
  parameters:
    value: '-0.2e3'
  states: {}
- name: lsb_co_freq_low
  id: variable
  parameters:
    value: '-2.8e3'
  states: {}
- name: nfm_co_freq
  id: variable
  parameters:
    value: 7.5e3
  states: {}
- name: offset_freq
  id: variable
  parameters:
    value: target_freq-sdr_freq
  states: {}
- name: receive_width
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sdr_freq
  id: variable
  parameters:
    value: 94.5e6
  states: {}
- name: sdr_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,3,1,1
    orient: Qt.Vertical
    start: 28e6
    step: 100e3
    stop: 1.7e9
    value: 94.5e6
  states: {state: disabled}
- name: sdr_samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: squelch
  id: variable
  parameters:
    value: '-70'
  states: {}
- name: syn_mode
  id: variable
  parameters:
    value: '0'
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 94.5e6
  states: {}
- name: usb_co_freq_high
  id: variable
  parameters:
    value: 2.8e3
  states: {}
- name: usb_co_freq_low
  id: variable
  parameters:
    value: 0.2e3
  states: {}
- name: wfm_co_freq
  id: variable
  parameters:
    value: 7.5e4
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-1'
    reference: '0.02'
    type: float
  states: {state: disabled}
- name: analog_agc_xx_0_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '6e-4'
    reference: audio_value
    type: float
  states: {state: disabled}
- name: analog_agc_xx_0_2
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-1'
    reference: '0.02'
    type: float
  states: {state: disabled}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: sdr_samp_rate/50
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: audio_value
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5.0e3
    quad_rate: int(sdr_samp_rate/50)
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-100000'
    offset: '0'
    phase: '0'
    samp_rate: sdr_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-offset_freq'
    offset: '0'
    phase: '0'
    samp_rate: sdr_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {state: disabled}
- name: analog_simple_squelch_cc_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: analog_simple_squelch_cc_2
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: analog_simple_squelch_cc_3
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: analog_simple_squelch_cc_4
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: sdr_samp_rate / 10
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '5'
    gain: '1'
    high_cutoff_freq: usb_co_freq_high
    low_cutoff_freq: usb_co_freq_low
    samp_rate: sdr_samp_rate/10
    type: fir_filter_ccc
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '5'
    gain: '1'
    high_cutoff_freq: lsb_co_freq_high
    low_cutoff_freq: lsb_co_freq_low
    samp_rate: sdr_samp_rate/10
    type: fir_filter_ccc
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: '100'
    offset: '0'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '0'
    num_outputs: '5'
    output_index: demod_mode
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: demod_mode
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: nfm_co_freq
    decim: '5'
    gain: '1'
    samp_rate: sdr_samp_rate/10
    type: fir_filter_ccf
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: am_co_freq
    decim: '5'
    gain: '1'
    samp_rate: sdr_samp_rate/10
    type: fir_filter_ccf
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: receive_width
    decim: '10'
    gain: '1'
    samp_rate: sdr_samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: wfm_co_freq
    decim: '1'
    gain: '1'
    samp_rate: sdr_samp_rate/10
    type: fir_filter_ccf
    width: '25000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sdr_samp_rate
    fc: sdr_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    name: '"mixed"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: dev_args
    bb_gain0: gain_bb
    freq0: sdr_freq
    gain0: gain_rf
    gain_mode0: 'False'
    if_gain0: gain_if
    sample_rate: sdr_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
    vlen: '1024'
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: complex
    vlen: '1024'
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_selector_0_0, '0']
- [analog_agc_xx_0_0_0, '0', audio_sink_0, '0']
- [analog_agc_xx_0_2, '0', audio_sink_0, '0']
- [analog_am_demod_cf_0, '0', blocks_selector_0_0, '0']
- [analog_const_source_x_0, '0', blocks_multiply_xx_1_0, '1']
- [analog_nbfm_rx_0, '0', blocks_selector_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [analog_simple_squelch_cc_0, '0', blocks_complex_to_mag_0, '0']
- [analog_simple_squelch_cc_1, '0', analog_nbfm_rx_0, '0']
- [analog_simple_squelch_cc_2, '0', analog_wfm_rcv_0, '0']
- [analog_simple_squelch_cc_3, '0', blocks_complex_to_real_0, '0']
- [analog_simple_squelch_cc_4, '0', blocks_complex_to_real_0_0, '0']
- [analog_wfm_rcv_0, '0', blocks_selector_0_0, '2']
- [band_pass_filter_0, '0', analog_simple_squelch_cc_3, '0']
- [band_pass_filter_0_0, '0', analog_simple_squelch_cc_4, '0']
- [blocks_complex_to_mag_0, '0', blocks_selector_0_0, '0']
- [blocks_complex_to_mag_0, '0', dc_blocker_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_selector_0_0, '3']
- [blocks_complex_to_real_0_0, '0', blocks_selector_0_0, '4']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0_0_0, '0']
- [blocks_multiply_xx_1_0, '0', audio_sink_0, '0']
- [blocks_selector_0, '0', low_pass_filter_0_0, '0']
- [blocks_selector_0, '1', low_pass_filter_0, '0']
- [blocks_selector_0, '2', low_pass_filter_0_1, '0']
- [blocks_selector_0, '3', band_pass_filter_0, '0']
- [blocks_selector_0, '4', band_pass_filter_0_0, '0']
- [blocks_selector_0_0, '0', analog_agc_xx_0_0_0, '0']
- [blocks_selector_0_0, '0', analog_agc_xx_0_2, '0']
- [blocks_selector_0_0, '0', blocks_multiply_xx_1_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', zeromq_pub_sink_0_0, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [dc_blocker_xx_0, '0', blocks_selector_0_0, '0']
- [fft_vxx_0, '0', zeromq_pub_sink_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_1, '0']
- [low_pass_filter_0_0, '0', analog_am_demod_cf_0, '0']
- [low_pass_filter_0_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_selector_0, '0']
- [low_pass_filter_0_1, '0', analog_simple_squelch_cc_2, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_1, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
